TYPE MachineSetting :
STRUCT
	targetSpeed : INT;
	currentSpeed : INT;
	machineName : STRING;
END_STRUCT
END_TYPE
